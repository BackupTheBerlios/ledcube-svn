# IAR project Backup of Cube_Demo.ewp, settings and files
configuration Cube_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\inc; ..\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cube_Demo.srec
  ILINK.IlinkOutputFile: Cube_Demo.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../STM32F4-Discovery/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../CMSIS/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../CMSISr/src/: stm32f4xx_spi.c
  group User
    ../: Cube.c Cube.h discovery-hardware.h Hardware.c Hardware.h hardwareSPI.c HardwareSPI.h Isr.c Isr.h main.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
